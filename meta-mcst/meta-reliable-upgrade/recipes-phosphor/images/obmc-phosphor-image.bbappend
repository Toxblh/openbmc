# Health-checked firmware update with fallback to the second BMC flash chip
OBMC_IMAGE_EXTRA_INSTALL_append = " reimu-bootguard"
