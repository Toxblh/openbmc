# pinned: a build must not change by itself (the tested revision)
SRCREV = "f378aaa09c5becd4446687efec6108f2a60c11c1"
