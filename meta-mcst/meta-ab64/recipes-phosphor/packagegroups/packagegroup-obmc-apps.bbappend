# reimu-fand owns the fans: no phosphor-fan-presence-tach (the inventory group
# pulled it in, and obmc-chassis-poweron@0 then Requires it, doing nothing here)
VIRTUAL-RUNTIME_obmc-fan-presence = ""
